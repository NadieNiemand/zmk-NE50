## config/boards/shields/noentiendo50/Kconfig.defconfig
```kconfig
if SHIELD_NOENTIENDO50

config ZMK_KEYBOARD_NAME
	default "NoEntiendo50"
	
endif
```
